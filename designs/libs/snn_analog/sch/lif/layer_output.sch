v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {lif/neurona_lvs.sym} 35 -10 0 0 {name=x6}
C {lif/neurona_lvs.sym} 35 240 0 0 {name=x7}
C {iopin.sym} -200 -80 0 0 {name=p1 lab=avdd}
C {iopin.sym} -200 -50 0 0 {name=p2 lab=avss}
C {lab_pin.sym} 35 -100 0 0 {name=p3 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 35 150 0 0 {name=p4 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 35 80 0 0 {name=p5 sig_type=std_logic lab=avss}
C {lab_pin.sym} 35 330 0 0 {name=p6 sig_type=std_logic lab=avss}
C {ipin.sym} -55 -10 0 0 {name=p7 lab=Iext1}
C {ipin.sym} -55 240 0 0 {name=p8 lab=Iext2}
C {opin.sym} 125 -30 0 0 {name=p9 lab=vout_1}
C {opin.sym} 125 10 0 0 {name=p10 lab=nvout_1}
C {opin.sym} 125 220 0 0 {name=p11 lab=vout_2}
C {opin.sym} 125 260 0 0 {name=p12 lab=nvout_2}
